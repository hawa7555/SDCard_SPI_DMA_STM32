# Keil uVision project sdCard_spiDma.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: sdCard_spiDma
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group main
    ./: main.c
software components: CMSIS:CORE 5.4.0, Device:GPIO 1.3, Device:Startup 1.0.0
